# Keil uVision project nuvoton-m051-osal.uvproj, settings and files
target nuvoton-m051-osal (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: M0516LDE Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0xFFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: nuvoton-m051-osal +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\..\trunk;..\spl\CMSIS\Include;..\spl\Device\Nuvoton\M051Series\Include;..\spl\StdDriver\inc;..\lib\stringx;..\lib\bufmgr;..\hal;..\osal;..\osal\portable;..\osal\portable\heapmgr;..\aps;..\app
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_M051Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group SPL\CMSIS
    ../spl/Device/Nuvoton/M051Series/Source/: system_M051Series.c
    ../spl/Device/Nuvoton/M051Series/Source/ARM/: startup_M051Series.s
  group SPL\STDDRIVER
    ../spl/StdDriver/src/: acmp.c adc.c clk.c ebi.c fmc.c gpio.c i2c.c pwm.c retarget.c spi.c sys.c timer.c uart.c wdt.c wwdt.c
  group LIB\STRINGX
    ../lib/stringx/: stringx.c
  group LIB\BUFMGR
    ../lib/bufmgr/: bufmgr.c
  group OSAL
    ../osal/: osal_system.c osal_task.c osal_timer.c osal_fifo.c osal_msg.c
  group OSAL\PORTABLE
    ../osal/portable/: osal_port.c
  group OSAL\PORTABLE\HEAPMGR
    ../osal/portable/heapmgr/: umm_info.c umm_integrity.c umm_malloc.c umm_poison.c
  group HAL
    ../hal/: hal_interrupt.c hal.c hal_uart.c hal_gpio.c hal_assert.c hal_i2c.c
  group APS
    ../aps/: aps_cli.c
  group APP
    ../App/: main.c
    ../app/: app.c app_task_cli.c app_event_cli.c app_event_por.c app_task_dongle.c
